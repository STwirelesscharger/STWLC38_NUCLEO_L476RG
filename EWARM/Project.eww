<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STWLC38_NUCLEO_L476RG.ewp</path>
  </project>
  <batchBuild />
</workspace>
